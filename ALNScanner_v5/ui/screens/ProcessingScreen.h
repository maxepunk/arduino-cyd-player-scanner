#pragma once

/**
 * @file ProcessingScreen.h
 * @brief Processing/sending modal screen for ALNScanner v5.0
 *
 * Displays video token processing image with "Sending..." overlay.
 * Auto-dismisses after 2.5 seconds (fire-and-forget pattern).
 *
 * Key Features:
 * - Shows processing image from SD card
 * - "Sending..." text overlay at bottom of screen
 * - Auto-timeout after 2.5 seconds
 * - Graceful fallback for missing images
 * - Thread-safe SD access via DisplayDriver
 *
 * Extracted from v4.1 monolithic codebase:
 * - Lines 2179-2235: displayProcessingImage() function
 * - Processing image display logic
 * - "Sending..." overlay rendering
 * - 2.5s auto-hide timer implementation
 *
 * Usage Pattern (from v4.1):
 * Video tokens are fire-and-forget - the scan is ALREADY sent to orchestrator
 * before this screen is shown. This screen provides visual feedback only.
 *
 * @code
 * // In UIStateMachine (after scan sent successfully)
 * TokenMetadata token = {...};  // From TokenService
 * auto screen = new ProcessingScreen(token);
 * currentScreen = screen;
 *
 * // In UIStateMachine::update() - poll for timeout
 * if (currentScreen->hasTimedOut()) {
 *     delete currentScreen;
 *     currentScreen = new ReadyScreen(...);
 * }
 * @endcode
 */

#include "../Screen.h"
#include "../../hal/DisplayDriver.h"
#include "../../hal/SDCard.h"
#include "../../config.h"

namespace ui {

/**
 * @class ProcessingScreen
 * @brief Modal screen showing video token processing with auto-dismiss
 *
 * Implementation Notes:
 * 1. Constructor stores imagePath and capture display timestamp
 * 2. onRender() displays image + overlay (called once by UIStateMachine)
 * 3. hasTimedOut() polled by UIStateMachine to trigger auto-dismiss
 * 4. No manual dismiss - timeout only (unlike TokenDisplayScreen)
 *
 * Visual Layout (240x320 display):
 * 
 *                     
 *   Processing Image    <- BMP from SD card
 *    (if available)   
 *                     
 *                     
 * $
 *    Sending...         <- White text overlay at y=200
 * 
 *
 * Extracted from v4.1 lines 2179-2235
 */
class ProcessingScreen : public Screen {
public:
    /**
     * @brief Construct processing screen with token metadata
     * @param token    Token metadata (used to construct image path)
     * @param label    Overlay text. Default "Sending..." (normal video
     *                 treatment). Decision A4: when the video cannot play
     *                 (scan queued offline, video busy, VLC down) the
     *                 caller passes "VIDEO UNAVAILABLE" instead.
     * @param sublabel Optional second overlay line (e.g., "Rescan later").
     *
     * Stores timestamp for timeout calculation.
     * Image path is constructed from token.getImagePath().
     *
     * Extracted from v4.1 line 2179 (function entry)
     */
    ProcessingScreen(const models::TokenMetadata& token,
                     const String& label = "Sending...",
                     const String& sublabel = "")
        : _imagePath(token.getImagePath()), _label(label), _sublabel(sublabel),
          _displayTime(millis()) {
        LOG_INFO("[PROCESSING-SCREEN] Constructed for token: %s\n", token.tokenId.c_str());
        LOG_INFO("[PROCESSING-SCREEN] Image path: %s\n", _imagePath.c_str());
        LOG_INFO("[PROCESSING-SCREEN] Label: %s%s%s\n", _label.c_str(),
                 _sublabel.length() > 0 ? " / " : "", _sublabel.c_str());
        LOG_INFO("[PROCESSING-SCREEN] Display timestamp: %lu ms\n", _displayTime);
    }

    /**
     * @brief Check if 2.5 second timeout has elapsed
     * @return true if screen should auto-dismiss, false otherwise
     *
     * Called by UIStateMachine::update() to trigger transition back to ReadyScreen.
     *
     * Extracted from v4.1 lines 2227-2232 (auto-hide timer logic)
     */
    bool hasTimedOut() const {
        unsigned long elapsed = millis() - _displayTime;
        bool timedOut = elapsed >= timing::PROCESSING_MODAL_TIMEOUT_MS;

        if (timedOut) {
            LOG_INFO("[PROCESSING-SCREEN] Timeout reached (elapsed: %lu ms)\n", elapsed);
        }

        return timedOut;
    }

protected:
    /**
     * @brief Render processing image with "Sending..." overlay
     * @param display DisplayDriver reference for rendering
     *
     * Rendering Flow:
     * 1. Attempt to load processing image from SD card
     * 2. If image missing/failed: Show black screen with centered "Sending..." text
     * 3. Regardless of image load: Add "Sending..." overlay at bottom of screen
     *
     * CRITICAL: Uses DisplayDriver::drawBMP() which implements Constitution-compliant
     * SPI bus management (SD read FIRST, TFT lock SECOND).
     *
     * Thread Safety: DisplayDriver handles SD mutex acquisition internally.
     *
     * Extracted from v4.1 lines 2184-2223 (image load and overlay rendering)
     */
    void onRender(hal::DisplayDriver& display) override {
        LOG_INFO("\n[PROCESSING-SCREEN] PPP RENDERING START PPP\n");
        LOG_INFO("[PROCESSING-SCREEN] Image path: %s\n",
                 _imagePath.length() > 0 ? _imagePath.c_str() : "(empty)");
        LOG_INFO("[PROCESSING-SCREEN] Free heap: %d bytes\n", ESP.getFreeHeap());

        bool imageLoaded = false;

        // Attempt to load processing image from SD card
        // (DisplayDriver handles SD mutex and file existence checks)
        if (_imagePath.length() > 0) {
            LOG_INFO("[PROCESSING-SCREEN] Loading image: %s\n", _imagePath.c_str());
            imageLoaded = display.drawBMP(_imagePath);

            if (imageLoaded) {
                LOG_INFO("[PROCESSING-SCREEN]  Image loaded successfully\n");
            } else {
                LOG_INFO("[PROCESSING-SCREEN]  Image load failed\n");
            }
        } else {
            LOG_INFO("[PROCESSING-SCREEN] No image path provided\n");
        }

        // Long labels (e.g. "VIDEO UNAVAILABLE", 17 chars) don't fit at
        // text size 3 on the 240px-wide display (~11 chars max); drop to
        // size 2 and a smaller left margin for anything longer.
        const bool compact = _label.length() > 11;
        const uint8_t labelTextSize = compact ? 2 : 3;
        const int16_t labelX = compact ? 18 : 40;

        // Fallback display for missing/failed image
        // Show black screen with centered label text
        // (Extracted from v4.1 lines 2208-2215)
        if (!imageLoaded) {
            LOG_INFO("[PROCESSING-SCREEN] Using fallback: text-only display\n");
            auto& tft = display.getTFT();
            tft.fillScreen(TFT_BLACK);
            tft.setTextColor(TFT_WHITE, TFT_BLACK);
            tft.setTextSize(labelTextSize);
            tft.setCursor(labelX, 100);  // Centered on screen
            tft.println(_label);
        }

        // Add label overlay at bottom of screen ("Sending..." normally;
        // "VIDEO UNAVAILABLE" when the video cannot play — decision A4)
        // This overlay is shown REGARDLESS of image load success
        // (Extracted from v4.1 lines 2217-2223)
        auto& tft = display.getTFT();
        tft.setTextColor(TFT_WHITE, TFT_BLACK);
        tft.setTextSize(labelTextSize);
        tft.setCursor(labelX, 200);  // Bottom of screen (240x320 display)
        tft.println(_label);
        if (_sublabel.length() > 0) {
            tft.setTextSize(2);
            tft.setCursor(18, 232);
            tft.println(_sublabel);
        }
        LOG_INFO("[PROCESSING-SCREEN]  Overlay added: '%s'\n", _label.c_str());

        LOG_INFO("[PROCESSING-SCREEN] Free heap after render: %d bytes\n", ESP.getFreeHeap());
        LOG_INFO("[PROCESSING-SCREEN] PPP RENDERING END PPP\n\n");
    }

private:
    String _imagePath;      ///< Path to processing image (e.g., "/images/jaw001.bmp")
    String _label;          ///< Overlay text ("Sending..." or "VIDEO UNAVAILABLE")
    String _sublabel;       ///< Optional second overlay line ("Rescan later")
    uint32_t _displayTime;  ///< Timestamp when screen was constructed (for timeout)
};

} // namespace ui

/**
 * IMPLEMENTATION NOTES (from v4.1 extraction)
 *
 * 1. FIRE-AND-FORGET PATTERN
 *    - Scan is ALREADY sent to orchestrator before this screen is shown
 *    - This screen provides visual feedback only (not a loading spinner)
 *    - Auto-dismiss after 2.5 seconds - no user interaction needed
 *    - Contrasts with TokenDisplayScreen (persistent, manual dismiss)
 *
 * 2. AUTO-TIMEOUT MECHANISM
 *    - Constructor captures timestamp: _displayTime = millis()
 *    - hasTimedOut() checks: millis() - _displayTime >= 2500ms
 *    - UIStateMachine polls hasTimedOut() in update() loop
 *    - On timeout: Delete ProcessingScreen, transition to ReadyScreen
 *
 *    v4.1 used blocking delay(2500) - NOT POSSIBLE in state machine!
 *    v5.0 uses polling pattern to maintain event loop responsiveness
 *
 * 3. IMAGE FILE NAMING
 *    - Video tokens and regular tokens use SAME file paths
 *    - Example: "/images/jaw001.bmp" (same as regular token image)
 *    - NO special suffixes or separate directories
 *    - Distinction is in metadata only (video field in tokens.json)
 *
 * 4. OVERLAY RENDERING
 *    - "Sending..." text at y=200 (bottom third of 320px screen)
 *    - White text on black background (TFT_WHITE, TFT_BLACK)
 *    - Text size 3 for visibility
 *    - Cursor at x=40 for left margin
 *    - Overlay shown REGARDLESS of image load success
 *
 * 5. FALLBACK DISPLAY
 *    - If image missing/failed: Black screen with centered "Sending..."
 *    - Cursor at (40, 100) for vertical centering
 *    - Same text style as overlay (size 3, white on black)
 *    - Ensures user always sees feedback even without image file
 *
 * 6. THREAD SAFETY
 *    - DisplayDriver::drawBMP() handles SD mutex acquisition
 *    - No direct SD card access in this class
 *    - No shared state mutations (read-only after construction)
 *    - Safe to call from any thread (typically Core 1 main loop)
 *
 * 7. MEMORY MANAGEMENT
 *    - No heap allocations in this class
 *    - imagePath stored by value (String copy)
 *    - DisplayDriver handles row buffer allocation internally
 *    - Screen object deleted by UIStateMachine after timeout
 *
 * 8. EXTRACTED FROM v4.1 LINES
 *    - Lines 2179-2183: Function entry, logging, heap check
 *    - Lines 2184-2205: Image loading attempt with SD mutex
 *    - Lines 2208-2215: Fallback text-only display
 *    - Lines 2217-2223: "Sending..." overlay rendering
 *    - Lines 2227-2232: Auto-hide timer (converted to polling)
 *    - Lines 2234-2235: Function exit logging
 *
 * 9. DIFFERENCES FROM v4.1
 *    - v4.1: Blocking delay(2500) for auto-hide
 *    - v5.0: Polling hasTimedOut() for state machine integration
 *
 *    - v4.1: Direct SD mutex acquisition (sdTakeMutex)
 *    - v5.0: DisplayDriver handles mutex internally
 *
 *    - v4.1: Direct tft global variable access
 *    - v5.0: DisplayDriver::getTFT() method
 *
 * 10. INTEGRATION WITH UIStateMachine
 *     UIStateMachine responsibilities:
 *     - Construct ProcessingScreen after successful scan upload
 *     - Call render() once to display screen
 *     - Poll hasTimedOut() in update() loop
 *     - Delete ProcessingScreen and transition to ReadyScreen on timeout
 *
 *     Example UIStateMachine::update() pseudo-code:
 *     @code
 *     if (currentScreen == PROCESSING && processingScreen->hasTimedOut()) {
 *         delete processingScreen;
 *         currentScreen = new ReadyScreen(...);
 *         currentScreen->render(display);
 *     }
 *     @endcode
 */
