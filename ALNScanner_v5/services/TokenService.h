#pragma once

/**
 * @file TokenService.h
 * @brief Token database management service for ALNScanner v5.0
 *
 * Manages token metadata loading and lookup from the SD card.
 * Uses std::vector for dynamic token storage (no fixed-size limit).
 *
 * Key Features:
 * - Singleton pattern for global access
 * - Dynamic token storage (std::vector)
 * - Thread-safe SD card access via hal::SDCard::Lock
 * - Efficient linear search for token lookup
 *
 * Extracted from v4.1 monolithic codebase:
 * - Lines 2092-2137: loadTokenDatabase()
 * - Lines 2139-2146: getTokenMetadata()
 */

#include <Arduino.h>
#include <ArduinoJson.h>
#include <vector>
#include "../models/Token.h"
#include "../hal/SDCard.h"
#include "../config.h"

namespace services {

/**
 * @class TokenService
 * @brief Singleton token database manager
 *
 * Usage Pattern:
 * @code
 * auto& tokenSvc = services::TokenService::getInstance();
 *
 * // Load from SD card at boot
 * if (tokenSvc.loadDatabaseFromSD()) {
 *     Serial.printf("Loaded %d tokens\n", tokenSvc.getCount());
 * }
 *
 * // Query token metadata
 * const auto* token = tokenSvc.get("ghost01");
 * @endcode
 */
class TokenService {
public:
    /**
     * @brief Get singleton instance
     * @return Reference to the global TokenService instance
     */
    static TokenService& getInstance() {
        static TokenService instance;
        return instance;
    }

    //  LIFECYCLE 

    /**
     * @brief Load token database from SD card (/tokens.json)
     * @return true if database loaded successfully, false if file not found or parse error
     *
     * Extracted from v4.1 lines 2092-2137 (loadTokenDatabase)
     *
     * Expected JSON format:
     * {
     *   "tokens": {
     *     "ghost01": {},
     *     "ghost02": {},
     *     ...
     *   }
     * }
     *
     * Entry VALUES are ignored entirely — a ghost is defined by its key.
     * Image and audio paths are constructed from the tokenId and their
     * presence is decided by what is actually on the card.
     */
    bool loadDatabaseFromSD() {
        LOG_INFO("[TOKEN-SVC] Loading token database from SD...\n");

        // Thread-safe SD access using RAII lock
        hal::SDCard::Lock lock("TokenService::loadDatabase");
        if (!lock.acquired()) {
            LOG_ERROR("TOKEN-SVC", "Could not acquire SD mutex");
            return false;
        }

        // Open tokens.json file
        File file = SD.open(paths::TOKEN_DB_FILE, FILE_READ);
        if (!file) {
            LOG_INFO("[TOKEN-SVC] tokens.json not found (OK for empty database)\n");
            return false;
        }

        // Parse JSON using ArduinoJson
        JsonDocument doc;
        DeserializationError error = deserializeJson(doc, file);
        file.close();

        if (error) {
            LOG_ERROR("TOKEN-SVC", "JSON parse error");
            Serial.printf("        Error: %s\n", error.c_str());
            return false;
        }

        // Clear existing tokens
        _tokens.clear();

        // Extract tokens from JSON
        JsonObject tokens = doc["tokens"];
        if (!tokens) {
            LOG_ERROR("TOKEN-SVC", "Missing 'tokens' object in JSON");
            return false;
        }

        // Iterate through token entries
        for (JsonPair kv : tokens) {
            models::TokenMetadata token;
            token.tokenId = String(kv.key().c_str());

            // The entry's value is deliberately ignored. A ghost is defined
            // solely by its key; image and audio paths are constructed from
            // the tokenId, and their presence is decided by what is actually
            // on the card, not by what tokens.json claims. This keeps the
            // file a non-technical person edits down to a list of names.
            _tokens.push_back(token);
        }

        LOG_INFO("[TOKEN-SVC] Loaded %d tokens from database\n", _tokens.size());
        return true;
    }

    //  QUERIES 

    /**
     * @brief Get token metadata by ID
     * @param tokenId Token identifier (e.g., "kaa001" or "04A1B2C3")
     * @return Pointer to TokenMetadata if found, nullptr otherwise
     *
     * Extracted from v4.1 lines 2139-2146 (getTokenMetadata)
     *
     * Uses linear search - acceptable for typical token counts (<100).
     * For larger databases (>1000 tokens), consider std::unordered_map.
     */
    const models::TokenMetadata* get(const String& tokenId) const {
        for (const auto& token : _tokens) {
            if (token.tokenId == tokenId) {
                return &token;
            }
        }
        return nullptr;
    }

    /**
     * @brief Check if token exists in database
     * @param tokenId Token identifier
     * @return true if token found, false otherwise
     */
    bool exists(const String& tokenId) const {
        return (get(tokenId) != nullptr);
    }

    /**
     * @brief Get number of tokens in database
     * @return Token count
     */
    int getCount() const {
        return _tokens.size();
    }

    /**
     * @brief Print token database to serial (limited count)
     * @param maxTokens Maximum number of tokens to print (default: 10)
     */
    void printDatabase(int maxTokens = 10) const {
        Serial.println("\n[TOKEN-SVC] PPP TOKEN DATABASE PPP");
        Serial.printf("Total tokens: %d\n", _tokens.size());

        int count = 0;
        for (const auto& token : _tokens) {
            if (count >= maxTokens) {
                Serial.printf("... and %d more tokens\n", _tokens.size() - maxTokens);
                break;
            }

            // Report what is actually ON THE CARD, not what tokens.json
            // claims. This is the fastest way for whoever built the card to
            // spot a misnamed or missing file.
            auto& sd = hal::SDCard::getInstance();
            Serial.printf("\n[%d] %s\n", count + 1, token.tokenId.c_str());
            Serial.printf("    Image: %-40s %s\n",
                          token.getImagePath().c_str(),
                          sd.exists(token.getImagePath()) ? "FOUND" : "missing");
            Serial.printf("    Audio: %-40s %s\n",
                          token.getAudioPath().c_str(),
                          sd.exists(token.getAudioPath()) ? "FOUND" : "missing");

            count++;
        }

        Serial.println("[TOKEN-SVC] PPPPPPPPPPPPPPPPPPPPPPP\n");
    }

    /**
     * @brief Print single token details
     * @param tokenId Token identifier
     */
    void printToken(const String& tokenId) const {
        const auto* token = get(tokenId);
        if (token) {
            token->print();
        } else {
            Serial.printf("[TOKEN-SVC] Token not found: %s\n", tokenId.c_str());
        }
    }

    /**
     * @brief Clear token database (for testing)
     */
    void clear() {
        _tokens.clear();
        LOG_INFO("[TOKEN-SVC] Token database cleared\n");
    }

private:
    // Singleton pattern - private constructors
    TokenService() = default;
    ~TokenService() = default;
    TokenService(const TokenService&) = delete;
    TokenService& operator=(const TokenService&) = delete;

    // Token storage (dynamic vector, no fixed limit)
    std::vector<models::TokenMetadata> _tokens;
};

} // namespace services

/**
 * IMPLEMENTATION NOTES
 *
 * 1. MEMORY EFFICIENCY
 *    - v4.1 used fixed array: TokenMetadata tokenDatabase[50] (fixed limit)
 *    - v5.0 uses std::vector: dynamic allocation, grows as needed
 *    - Typical token count: 10-50 tokens (~2KB RAM)
 *    - Max realistic: 200 tokens (~8KB RAM, still acceptable)
 *
 * 2. THREAD SAFETY
 *    - All SD operations use hal::SDCard::Lock (RAII mutex)
 *    - No internal state modification after loadDatabaseFromSD()
 *    - Read-only queries (get, exists, getCount) are thread-safe
 *    - Sync operation uses long timeout (2000ms) for large files
 *
 * 3. ERROR HANDLING
 *    - Missing tokens.json returns false (not an error, database optional)
 *    - JSON parse errors logged and return false
 *    - Network errors during sync return false
 *    - Size validation prevents OOM (max 50KB token database)
 *
 * 4. ORCHESTRATOR INTEGRATION
 *    - syncFromOrchestrator() fetches from /api/tokens endpoint
 *    - Saves raw JSON to SD card (no in-memory parsing during sync)
 *    - Caller must call loadDatabaseFromSD() after sync to reload
 *    - Pattern: sync() � loadDatabaseFromSD() � ready for queries
 *
 * 5. LOOKUP PERFORMANCE
 *    - Linear search O(n) acceptable for <100 tokens
 *    - Average case: ~25 comparisons for 50 tokens
 *    - Worst case: 50 comparisons (microseconds on ESP32)
 *    - For >1000 tokens: consider std::unordered_map O(1) lookup
 *
 * 6. ARDUINO JSON USAGE
 *    - Uses JsonDocument (auto-sized, no explicit capacity)
 *    - ArduinoJson v6+ syntax (deserializeJson, JsonObject)
 *    - Automatically handles JSON object iteration
 *    - Filters: tokenData["video"] | "" (default to empty string)
 *
 * 7. INTEGRATION WITH MODELS
 *    - Uses models::TokenMetadata from models/Token.h
 *    - Leverages TokenMetadata helper methods:
 *      - isVideoToken() - Check if token has video field
 *      - getImagePath() - Get display image path
 *      - getAudioPath() - Get audio file path
 *      - getProcessingImagePath() - Get video processing image path
 *
 * 8. EXTRACTED CODE MAPPING
 *    - loadDatabaseFromSD() � v4.1 lines 2092-2137
 *    - get() � v4.1 lines 2139-2146
 *    - syncFromOrchestrator() � v4.1 lines 1571-1634
 *    - Helper methods (hasVideoField, etc.) moved to TokenMetadata model
 */
