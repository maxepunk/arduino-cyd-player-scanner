#pragma once

/**
 * @file TokenService.h
 * @brief Token database management service for ALNScanner v5.0
 *
 * Manages token metadata loading, lookup, and orchestrator synchronization.
 * Uses std::vector for dynamic token storage (no fixed-size limit).
 *
 * Key Features:
 * - Singleton pattern for global access
 * - Dynamic token storage (std::vector)
 * - Thread-safe SD card access via hal::SDCard::Lock
 * - Orchestrator synchronization with size validation
 * - Efficient linear search for token lookup
 *
 * Extracted from v4.1 monolithic codebase:
 * - Lines 1571-1634: syncTokenDatabase()
 * - Lines 2092-2137: loadTokenDatabase()
 * - Lines 2139-2146: getTokenMetadata()
 * - Lines 2148-2177: hasVideoField(), getProcessingImagePath()
 */

#include <Arduino.h>
#include <ArduinoJson.h>
#include <vector>
#include "../models/Token.h"
#include "../hal/SDCard.h"
#include "../config.h"
#include "OrchestratorService.h"  // Need full definition for method calls

namespace services {

/**
 * @class TokenService
 * @brief Singleton token database manager
 *
 * Usage Pattern:
 * @code
 * auto& tokenSvc = services::TokenService::getInstance();
 *
 * // Load from SD card at boot
 * if (tokenSvc.loadDatabaseFromSD()) {
 *     Serial.printf("Loaded %d tokens\n", tokenSvc.getCount());
 * }
 *
 * // Query token metadata
 * const auto* token = tokenSvc.get("kaa001");
 * if (token) {
 *     Serial.printf("Video: %s\n", token->isVideoToken() ? "YES" : "NO");
 * }
 *
 * // Sync from orchestrator (if configured)
 * if (tokenSvc.syncFromOrchestrator("http://10.0.0.177:3000")) {
 *     tokenSvc.loadDatabaseFromSD();  // Reload after sync
 * }
 * @endcode
 */
class TokenService {
public:
    /**
     * @brief Get singleton instance
     * @return Reference to the global TokenService instance
     */
    static TokenService& getInstance() {
        static TokenService instance;
        return instance;
    }

    //  LIFECYCLE 

    /**
     * @brief Load token database from SD card (/tokens.json)
     * @return true if database loaded successfully, false if file not found or parse error
     *
     * Extracted from v4.1 lines 2092-2137 (loadTokenDatabase)
     *
     * Expected JSON format:
     * {
     *   "tokens": {
     *     "kaa001": {
     *       "video": "kaa001.mp4"
     *     },
     *     "jaw001": {
     *       "video": ""
     *     },
     *     ...
     *   }
     * }
     *
     * Note: image/audio/processingImage fields are ignored (paths constructed from tokenId)
     */
    bool loadDatabaseFromSD() {
        LOG_INFO("[TOKEN-SVC] Loading token database from SD...\n");

        // Thread-safe SD access using RAII lock
        hal::SDCard::Lock lock("TokenService::loadDatabase");
        if (!lock.acquired()) {
            LOG_ERROR("TOKEN-SVC", "Could not acquire SD mutex");
            return false;
        }

        // Open tokens.json file
        File file = SD.open(paths::TOKEN_DB_FILE, FILE_READ);
        if (!file) {
            LOG_INFO("[TOKEN-SVC] tokens.json not found (OK for empty database)\n");
            return false;
        }

        // Parse JSON using ArduinoJson
        JsonDocument doc;
        DeserializationError error = deserializeJson(doc, file);
        file.close();

        if (error) {
            LOG_ERROR("TOKEN-SVC", "JSON parse error");
            Serial.printf("        Error: %s\n", error.c_str());
            return false;
        }

        // Clear existing tokens
        _tokens.clear();

        // Extract tokens from JSON
        JsonObject tokens = doc["tokens"];
        if (!tokens) {
            LOG_ERROR("TOKEN-SVC", "Missing 'tokens' object in JSON");
            return false;
        }

        // Iterate through token entries
        for (JsonPair kv : tokens) {
            models::TokenMetadata token;
            token.tokenId = String(kv.key().c_str());

            JsonObject tokenData = kv.value();
            token.video = tokenData["video"] | "";
            // Note: image, audio, processingImage fields removed from v5
            // Paths are now ALWAYS constructed from tokenId via getImagePath()/getAudioPath()

            _tokens.push_back(token);
        }

        LOG_INFO("[TOKEN-SVC] Loaded %d tokens from database\n", _tokens.size());
        return true;
    }

    //  QUERIES 

    /**
     * @brief Get token metadata by ID
     * @param tokenId Token identifier (e.g., "kaa001" or "04A1B2C3")
     * @return Pointer to TokenMetadata if found, nullptr otherwise
     *
     * Extracted from v4.1 lines 2139-2146 (getTokenMetadata)
     *
     * Uses linear search - acceptable for typical token counts (<100).
     * For larger databases (>1000 tokens), consider std::unordered_map.
     */
    const models::TokenMetadata* get(const String& tokenId) const {
        for (const auto& token : _tokens) {
            if (token.tokenId == tokenId) {
                return &token;
            }
        }
        return nullptr;
    }

    /**
     * @brief Check if token exists in database
     * @param tokenId Token identifier
     * @return true if token found, false otherwise
     */
    bool exists(const String& tokenId) const {
        return (get(tokenId) != nullptr);
    }

    /**
     * @brief Get number of tokens in database
     * @return Token count
     */
    int getCount() const {
        return _tokens.size();
    }

    //  SYNCHRONIZATION 

    /**
     * @brief Sync token database from orchestrator
     * @param orchestratorURL Base URL of orchestrator (e.g., "http://10.0.0.177:3000")
     * @return true if sync successful, false on network or file error
     *
     * Extracted from v4.1 lines 1571-1634 (syncTokenDatabase)
     *
     * This method:
     * 1. Fetches token database from orchestrator (GET /api/tokens)
     * 2. Validates response size (max 50KB to prevent OOM)
     * 3. Saves JSON payload to SD card (/tokens.json)
     * 4. Does NOT reload database automatically (caller must call loadDatabaseFromSD())
     *
     * Note: Use WiFi connection check before calling this method.
     */
    bool syncFromOrchestrator(const String& orchestratorURL, OrchestratorService& orch) {
        Serial.println("\n[TOKEN-SVC] PPP TOKEN DATABASE SYNC START PPP");
        Serial.printf("[TOKEN-SVC] Free heap: %d bytes\n", ESP.getFreeHeap());

        if (orchestratorURL.length() == 0) {
            LOG_ERROR("TOKEN-SVC", "Orchestrator URL not configured");
            return false;
        }

        // Construct API endpoint
        String url = orchestratorURL + "/api/tokens";
        Serial.printf("[TOKEN-SVC] Fetching from: %s\n", url.c_str());
        // Use OrchestratorService HTTP methods (HTTPS + retry logic)
        String payload;
        int httpCode = orch.httpGETWithRetry(url, 30000, "token sync", payload);
        if (httpCode == 200) {
            // Check file size before reading to RAM (prevent OOM)
            int size = payload.length();
            Serial.printf("[TOKEN-SVC] Received HTTP 200, size: %d bytes\n", size);

            if (size > limits::MAX_TOKEN_DB_SIZE) {
                Serial.printf("[TOKEN-SVC]  FAILURE  Token DB too large (%d > %d bytes)\n",
                              size, limits::MAX_TOKEN_DB_SIZE);
                
                return false;
            }

            // Read response payload
            
            

            Serial.printf("[TOKEN-SVC] Payload read (%d bytes)\n", payload.length());

            // Save to SD card with mutex protection
            hal::SDCard::Lock lock("TokenService::sync", freertos_config::SD_MUTEX_LONG_TIMEOUT_MS);
            if (!lock.acquired()) {
                LOG_ERROR("TOKEN-SVC", "Could not acquire SD lock for sync");
                return false;
            }

            File file = SD.open(paths::TOKEN_DB_FILE, FILE_WRITE);
            if (!file) {
                LOG_ERROR("TOKEN-SVC", "Could not open tokens.json for writing");
                return false;
            }

            file.print(payload);
            file.flush();
            file.close();

            Serial.println("[TOKEN-SVC]  SUCCESS  Token database synced and saved");
            Serial.printf("[TOKEN-SVC] Free heap after sync: %d bytes\n", ESP.getFreeHeap());
            Serial.println("[TOKEN-SVC] PPP TOKEN DATABASE SYNC END PPP\n");
            return true;

        } else {
            Serial.printf("[TOKEN-SVC]  FAILURE  HTTP request failed (code: %d)\n", httpCode);
            
            Serial.println("[TOKEN-SVC] PPP TOKEN DATABASE SYNC END PPP\n");
            return false;
        }
    }

    //  DEBUG 

    /**
     * @brief Print token database to serial (limited count)
     * @param maxTokens Maximum number of tokens to print (default: 10)
     */
    void printDatabase(int maxTokens = 10) const {
        Serial.println("\n[TOKEN-SVC] PPP TOKEN DATABASE PPP");
        Serial.printf("Total tokens: %d\n", _tokens.size());

        int count = 0;
        for (const auto& token : _tokens) {
            if (count >= maxTokens) {
                Serial.printf("... and %d more tokens\n", _tokens.size() - maxTokens);
                break;
            }

            Serial.printf("\n[%d] %s\n", count + 1, token.tokenId.c_str());
            Serial.printf("    Video: %s\n", token.video.length() > 0 ? token.video.c_str() : "(none)");
            Serial.printf("    Image Path: %s\n", token.getImagePath().c_str());
            Serial.printf("    Audio Path: %s\n", token.getAudioPath().c_str());
            Serial.printf("    Is Video Token: %s\n", token.isVideoToken() ? "YES" : "NO");

            count++;
        }

        Serial.println("[TOKEN-SVC] PPPPPPPPPPPPPPPPPPPPPPP\n");
    }

    /**
     * @brief Print single token details
     * @param tokenId Token identifier
     */
    void printToken(const String& tokenId) const {
        const auto* token = get(tokenId);
        if (token) {
            token->print();
        } else {
            Serial.printf("[TOKEN-SVC] Token not found: %s\n", tokenId.c_str());
        }
    }

    /**
     * @brief Clear token database (for testing)
     */
    void clear() {
        _tokens.clear();
        LOG_INFO("[TOKEN-SVC] Token database cleared\n");
    }

private:
    // Singleton pattern - private constructors
    TokenService() = default;
    ~TokenService() = default;
    TokenService(const TokenService&) = delete;
    TokenService& operator=(const TokenService&) = delete;

    // Token storage (dynamic vector, no fixed limit)
    std::vector<models::TokenMetadata> _tokens;
};

} // namespace services

/**
 * IMPLEMENTATION NOTES
 *
 * 1. MEMORY EFFICIENCY
 *    - v4.1 used fixed array: TokenMetadata tokenDatabase[50] (fixed limit)
 *    - v5.0 uses std::vector: dynamic allocation, grows as needed
 *    - Typical token count: 10-50 tokens (~2KB RAM)
 *    - Max realistic: 200 tokens (~8KB RAM, still acceptable)
 *
 * 2. THREAD SAFETY
 *    - All SD operations use hal::SDCard::Lock (RAII mutex)
 *    - No internal state modification after loadDatabaseFromSD()
 *    - Read-only queries (get, exists, getCount) are thread-safe
 *    - Sync operation uses long timeout (2000ms) for large files
 *
 * 3. ERROR HANDLING
 *    - Missing tokens.json returns false (not an error, database optional)
 *    - JSON parse errors logged and return false
 *    - Network errors during sync return false
 *    - Size validation prevents OOM (max 50KB token database)
 *
 * 4. ORCHESTRATOR INTEGRATION
 *    - syncFromOrchestrator() fetches from /api/tokens endpoint
 *    - Saves raw JSON to SD card (no in-memory parsing during sync)
 *    - Caller must call loadDatabaseFromSD() after sync to reload
 *    - Pattern: sync() � loadDatabaseFromSD() � ready for queries
 *
 * 5. LOOKUP PERFORMANCE
 *    - Linear search O(n) acceptable for <100 tokens
 *    - Average case: ~25 comparisons for 50 tokens
 *    - Worst case: 50 comparisons (microseconds on ESP32)
 *    - For >1000 tokens: consider std::unordered_map O(1) lookup
 *
 * 6. ARDUINO JSON USAGE
 *    - Uses JsonDocument (auto-sized, no explicit capacity)
 *    - ArduinoJson v6+ syntax (deserializeJson, JsonObject)
 *    - Automatically handles JSON object iteration
 *    - Filters: tokenData["video"] | "" (default to empty string)
 *
 * 7. INTEGRATION WITH MODELS
 *    - Uses models::TokenMetadata from models/Token.h
 *    - Leverages TokenMetadata helper methods:
 *      - isVideoToken() - Check if token has video field
 *      - getImagePath() - Get display image path
 *      - getAudioPath() - Get audio file path
 *      - getProcessingImagePath() - Get video processing image path
 *
 * 8. EXTRACTED CODE MAPPING
 *    - loadDatabaseFromSD() � v4.1 lines 2092-2137
 *    - get() � v4.1 lines 2139-2146
 *    - syncFromOrchestrator() � v4.1 lines 1571-1634
 *    - Helper methods (hasVideoField, etc.) moved to TokenMetadata model
 */
